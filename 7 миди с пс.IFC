Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy: 7 миди.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[720]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[721]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[722]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[723]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[724]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[725]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[726]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[727]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[728]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[729]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[730]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[731]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[732]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[733]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[734]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[735]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[736]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[737]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[738]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[739]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[740]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[741]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[742]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[743]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[744]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[745]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[746]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[747]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[748]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[749]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[750]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[751]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[752]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[753]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[754]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[755]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[756]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[757]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[758]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[759]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 7 миди.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
